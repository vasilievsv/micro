# Keil uVision project MDK-ARM.uvprojx, settings and files
target stm32f1xx (ARM-ADS)
  device: STM32F100R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32VL-Discovery
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F100xB,HSE_VALUE=8000000U,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;C:\Developer\SDK\STM32\CMSIS\Device\ST\STM32F1xx\Include;C:\Developer\SDK\STM32\STM32F1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup/MDK-ARM
    ./: startup_stm32f100xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32f1xx_LL_Driver
    C:/Developer/SDK/STM32/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_utils.c stm32f1xx_ll_usart.c stm32f1xx_ll_tim.c stm32f1xx_ll_spi.c stm32f1xx_ll_rtc.c stm32f1xx_ll_rcc.c stm32f1xx_ll_pwr.c stm32f1xx_ll_gpio.c stm32f1xx_ll_exti.c stm32f1xx_ll_dma.c stm32f1xx_ll_dac.c stm32f1xx_ll_crc.c stm32f1xx_ll_adc.c
  group User
    ../Src/: main.c stm32f1xx_it.c
    ../src/: stm32f1xx_it_hostx.c
  group User/hostx
    ../src/hostx/: structs.h facade.h hostx_Clock.c hostx_Device.c hostx_Intercom.c hostx_Proc.c
  group User/hostx.api
    ../src/hostx.api/: api_CNC.c api_MCU.c api_PROTO.c api_VM.c _core.h
  group User/hostx/utils
    ../src/hostx/utils/: hxCRC32.c hxSleep.c
software components: CMSIS:CORE 4.3.0
